# Keil uVision project KPA_BDK2.uvprojx, settings and files
target KPA_BDK2 (6230000::V6.23::ARMCLANG)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: KPA_BDK2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Inc;                                                                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                               ../Drivers/CMSIS/Include;                                                                               ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                               ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                                               ..\my_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dac.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group My_lib
    ../my_lib/: vcp_time_segmentation.c modbus_rtu.c modbus_data_formater.c INA226.c INA226.h modbus_data_formater.h modbus_rtu.h vcp_time_segmentation.h my_GPIO.c my_GPIO.h my_UART.c my_UART.h led.c led.h my_SPI.h my_SPI.c Power_module.c Power_module.h analog_data.h my_MKO.c my_MKO.h AD7490.c AD7490.h MPP_Module.h MPP_Module.c LoRa.h LoRa.c avruser_CAN.c avruser_CAN.h
    ./: DEP_AD.c DEP_AD.h
software components: CMSIS:CORE 6.1.0
